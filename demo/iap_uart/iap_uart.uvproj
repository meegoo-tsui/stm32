# Keil uVision project iap_uart.uvproj, settings and files
target stm32f10x iap_uart (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: iap_uart +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STM3210B_EVAL,USE_STDPERIPH_DRIVER, USE_FULL_ASSERT, STM32F10X_MD, PRINTF_LEVEL=2
  c include: ..\..\sdk\CMSIS_V3.5.0\CoreSupport;..\..\sdk\CMSIS_V3.5.0\DeviceSupport\STM32F10x;..\..\sdk\STM32F10x_StdPeriph_Lib_V3.5.0\inc;..\..\sdk\STM32_I2C_CPAL_V1.1.0\inc;..\..\sdk\STM32_I2C_CPAL_V1.1.0\devices\stm32f10x;..\..\sdk\STM32F10x_App_Lib_V1.0.0\inc;.\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS_V3.5.0
    ../../sdk/CMSIS_V3.5.0/DeviceSupport/STM32F10x/arm/: startup_stm32f10x_md.s
    ../../sdk/CMSIS_V3.5.0/CoreSupport/: core_cm3.c
    ../../sdk/CMSIS_V3.5.0/DeviceSupport/STM32F10x/: system_stm32f10x.c
  group STM32F10x_StdPeriph_Lib_V3.5.0
    ../../sdk/STM32F10x_StdPeriph_Lib_V3.5.0/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ./src/: common.c download.c main.c stm32f10x_it.c upload.c ymodem.c
